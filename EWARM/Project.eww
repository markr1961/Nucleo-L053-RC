<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Nucleo-L083-rc-sbus-to-pwm.ewp</path>
  </project>
  <batchBuild />
</workspace>
